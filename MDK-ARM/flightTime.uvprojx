# Keil uVision project flightTime.uvprojx, settings and files
target flightTime (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: flightTime +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01
  c include: ../Core/Inc;../Src/vl53l0x;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/B-L475E-IOT01;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/BSP/B-L475E-IOT01
    ../Drivers/B-L475E-IOT01/: stm32l475e_iot01.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Application/User/vl53l0x
    ../Core/Src/vl53l0x/: vl53l0x_api_strings.c vl53l0x_api.c vl53l0x_api_ranging.c vl53l0x_platform_log.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_tof.c
software components: CMSIS:CORE 4.3.0
